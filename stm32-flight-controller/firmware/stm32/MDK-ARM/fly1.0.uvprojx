# Keil uVision project fly1.0.uvprojx, settings and files
target fly1.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: fly1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --c99 --no_strict --gnu
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FlightController/fc_core;../FlightController/fc_input;../FlightController/fc_estimator;../FlightController/fc_safety;../FlightController/fc_log;../FlightController/fc_cfg;../FlightController/fc_control;../FlightController/fc_output
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: bmi08a.c bmi08g.c bmi088.c ms5611.c sbus.c imu_bmi088_bus.c imu_bmi088_frontend.c fusion_mahony.c ringbuf_spsc.c timebase.c imu_bus_hal.c imu_bringup.c pipeline.c sync_pair.c autocal.c mixer.c motors.c log_uart.c main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Inc/: bmi08x_defs.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FC_Core
    ../FlightController/fc_core/: fc_core.c fc_time.c
  group FC_Input
    ../FlightController/fc_input/: fc_rc.c
  group FC_Estimator
    ../FlightController/fc_estimator/: fc_att.c fc_baro.c
  group FC_Safety
    ../FlightController/fc_safety/: fc_air.c fc_arm.c fc_fs.c
  group FC_Log
    ../FlightController/fc_log/: fc_evt.c fc_log.c
  group FC_Control
    ../FlightController/fc_control/: fc_control.c fc_throttle.c fc_mode.c fc_angle.c fc_rate.c fc_yaw.c fc_alt_hold.c
  group FC_Output
    ../FlightController/fc_output/: fc_mixer_out.c
software components: CMSIS:CORE 4.3.0
